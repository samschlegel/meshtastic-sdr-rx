options:
  parameters:
    comment: LoRa RX with SDRplay RSPdx R2
    generate_options: qt_gui
    id: lora_rx_sdrplay
    output_language: python
    title: LoRa RX - SDRplay RSPdx R2
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    comment: LoRa bandwidth in Hz
    value: '250000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: 915e6 for US, 868.1e6 for EU
    value: 913.125e6
  states: {}
- name: cr
  id: variable
  parameters:
    comment: Coding rate (1-4)
    value: '1'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: pay_len
  id: variable
  parameters:
    value: '255'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Must be integer multiple of bw
    value: '1000000'
  states: {}
- name: sf
  id: variable
  parameters:
    comment: Spreading factor (7-12)
    value: '9'
  states: {}
- name: soft_decoding
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: lora_sdr_crc_verif_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '2'
  states: {}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    center_freq: int(center_freq)
    impl_head: impl_head
    os_factor: int(samp_rate/bw)
    preamb_len: '17'
    sf: sf
    show_log_port: 'True'
    sync_word: '[0,0]'
  states: {}
- name: lora_sdr_gray_mapping_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_header_decoder_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    ldro: 'False'
    pay_len: pay_len
    print_header: 'False'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: 0,0,1,2
    name: '"Spectrum"'
    type: complex
    update_time: '0.05'
    ymax: '0'
    ymin: '-100'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: 1,0,1,2
    int_max: '0'
    int_min: '-100'
    name: '"Waterfall"'
    type: complex
    update_time: '0.05'
  states: {}
- name: sdrplay3_rspdxr2_0
  id: sdrplay3_rspdxr2
  parameters:
    AGC: 'False'
    agc_set_point: '-30'
    antenna: Antenna A
    bandwidth: '0'
    biasT: 'False'
    center_freq: center_freq
    dab_notch_filter: 'False'
    dc_offset_mode: 'False'
    debug_mode: 'False'
    freq_corr: '0'
    hdr_mode: 'False'
    if_gRdB: '40'
    iq_balance_mode: 'False'
    minoutbuf: int(np.ceil(samp_rate/bw*(2**sf+2)))
    output_type: fc32
    rf_gRLNA: '10'
    rf_gR_mode: LNA
    rf_gRdB: '12'
    rf_notch_filter: 'False'
    rsp_selector: ''
    sample_rate: samp_rate
    sample_sequence_gaps_check: 'False'
    show_gain_changes: 'False'
    synchronous_updates: 'False'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://0.0.0.0:20002
    comment: MediumFast port 20002
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_pub_sink_1
  id: zeromq_pub_sink
  parameters:
    address: tcp://0.0.0.0:20003
    comment: Raw IQ for dashboard
    timeout: '100'
    type: complex
  states: {}

connections:
- [lora_sdr_crc_verif_0, '0', zeromq_pub_sink_0, '0']
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_dewhitening_0, '0', lora_sdr_crc_verif_0, '0']
- [lora_sdr_fft_demod_0, '0', lora_sdr_gray_mapping_0, '0']
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_0, '0']
- [lora_sdr_gray_mapping_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_hamming_dec_0, '0', lora_sdr_header_decoder_0, '0']
- [lora_sdr_header_decoder_0, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_header_decoder_0, frame_info, lora_sdr_frame_sync_0, frame_info]
- [sdrplay3_rspdxr2_0, '0', lora_sdr_frame_sync_0, '0']
- [sdrplay3_rspdxr2_0, '0', qtgui_freq_sink_x_0, '0']
- [sdrplay3_rspdxr2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [sdrplay3_rspdxr2_0, '0', zeromq_pub_sink_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
